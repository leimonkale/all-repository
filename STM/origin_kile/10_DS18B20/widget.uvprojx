# Keil uVision project widget.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: widget
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: delay.c ds18b20.c main.c usart.c stm32f4xx_hal_msp.c
software components: CMSIS:CORE 4.3.0, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:Startup 2.6.2
